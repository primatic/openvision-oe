SRC_URI = "git://github.com/OpenVisionE2/lsdir.git;protocol=git"
