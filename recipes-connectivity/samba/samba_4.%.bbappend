FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

inherit upx_compress
