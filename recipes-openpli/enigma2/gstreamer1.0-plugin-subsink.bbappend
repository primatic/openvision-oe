SRC_URI = "git://github.com/christophecvr/gstreamer1.0-plugin-subsink.git;protocol=git"
