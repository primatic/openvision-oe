DEPENDS_remove += "\
	enigma2-plugin-extensions-openwebif \
"

DEPENDS_append += "\
	enigma2-plugin-extensions-openwebif-vision \
"
