SRC_URI = "git://github.com/oe-alliance/e2openplugin-CrossEPG.git;protocol=git"
