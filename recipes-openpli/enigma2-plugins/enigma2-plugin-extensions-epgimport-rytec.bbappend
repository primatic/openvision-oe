SRC_URI = "https://raw.githubusercontent.com/OpenVisionE2/hypercube-files/master/rytec.sources.xml.${PV}.gz"
