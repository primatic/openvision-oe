SRC_URI = "git://github.com/PLi-metas/minidlna.git \
			file://readymedia.sh \
			file://minidlna.conf \
"
