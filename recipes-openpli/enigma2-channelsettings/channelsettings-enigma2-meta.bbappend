DEPENDS = "\
	enigma2-plugin-settings-chveneburi \
	enigma2-plugin-settings-hans-19e-23e \
	enigma2-plugin-settings-hans-19e-23e-basis \
	enigma2-plugin-settings-hans-19e-23e-28e \
	enigma2-plugin-settings-hans-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e-rotating \
	enigma2-plugin-settings-hans-kabelnl \
	enigma2-plugin-settings-ziggo-casema-west \
	"
