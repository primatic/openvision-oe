SRC_URI = "git://github.com/OpenVisionE2/iptvplayer-bin-components.git"
