SRC_URI = "git://github.com/OpenVisionE2/astra-sm.git \
	file://version.patch \
	file://undef_dvb_net.patch \
	file://astra-sm \
	file://astra.conf \
	"
