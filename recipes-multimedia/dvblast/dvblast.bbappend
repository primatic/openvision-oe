SRC_URI = "git://github.com/OpenVisionE2/dvblast.git"
