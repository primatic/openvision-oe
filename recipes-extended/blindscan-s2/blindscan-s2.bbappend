LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b69b6d0feee577047e07a832c67d8076"
SRC_URI = "git://github.com/OpenVisionE2/blindscan-s2.git"
